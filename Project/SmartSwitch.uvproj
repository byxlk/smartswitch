# Keil uVision project SmartSwitch.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: SmartSwitch +hex
  AfterMake: H:\SmartSwitch_Project\smartswitch\Project\DelTempFile_CopyHex.bat
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ../Src/: delay.c GPIO.c main.c timer.c USART1.C misc.c Exti.c
    ./: Release.txt
